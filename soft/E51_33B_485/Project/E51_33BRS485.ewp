# IAR project E51_33BRS485.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 2
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: E51_33BRS485.hex
  ILINK.IlinkOutputFile: E51_33BRS485.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Application
    ../Application/: APP_BackLight.c APP_Backlight.h APP_Configure.h APP_Display.c APP_Display.h APP_KeyBoard.c APP_KeyBoard.h APP_Rs485.c APP_Rs485.h APP_RTC.c APP_RTC.h APP_Storage.c APP_Storage.h APP_Temperature.c APP_Temperature.h APP_ThreeFanOut.c APP_ThreeFanOut.h Main.c
  group Mod_Backlight
    ../Module/Mod_Backlight/Src/: Mod_Backlight.c Mod_Backlight.h
  group Mod_Backlight/Depend
    ../Module/Mod_Backlight/Depend/: BSP_Backlight.c BSP_Backlight.h
  group Mod_EEFlash
    ../Module/Mod_EEFlash/Src/: Mod_FlashStoBlockOf8Bits.c Mod_FlashStoBlockOf8Bits.h
  group Mod_EEFlash/Depend
    ../Module/Mod_EEFlash/Depend/: BSP_FlashEEM.c BSP_FlashEEM.h
  group Mod_IWDG
    ../Module/Mod_IWDG/Src/: Mod_IWDG.c Mod_IWDG.h
  group Mod_IWDG/Depend
    ../Module/Mod_IWDG/Depend/: BSP_IWDG.c BSP_IWDG.h
  group Mod_Keyboard
    ../Module/Mod_Keyboard/Src/: Mod_Keyboard.c Mod_Keyboard.h
  group Mod_Keyboard/Depend
    ../Module/Mod_Keyboard/Depend/: BSP_Keyboard.c BSP_Keyboard.h
  group Mod_LCD
    ../Module/Mod_LCD/Src/: Mod_LCD.c Mod_LCD.h
  group Mod_LCD/Depend
    ../Module/Mod_LCD/Depend/: BSP_LCD.c BSP_LCD.h
  group Mod_Modbus
    ../Module/Mod_Modbus/Src/: Mod_ModbusSlave.c Mod_ModbusSlave.h
  group Mod_Modbus/Depend
    ../Module/Mod_Modbus/Depend/: BSP_SlaveUart.c BSP_SlaveUart.h
  group Mod_NTC3380
    ../Module/Mod_NTC3380/Src/: Mod_NTC3380.c Mod_NTC3380.h
  group Mod_NTC3380/Depend
    ../Module/Mod_NTC3380/Depend/: BSP_NTC3380.c BSP_NTC3380.h
  group Mod_Relay
    ../Module/Mod_Relay/Src/: Mod_RelayPWM.c Mod_RelayPWM.h
  group Mod_Relay/Depend
    ../Module/Mod_Relay/Depend/: BSP_RelayPWM.c BSP_RelayPWM.h
  group Mod_SD3078
    ../Module/Mod_SD3078/Src/: Mod_SD3078.c Mod_SD3078.h
  group Mod_SD3078/Depend
    ../Module/Mod_SD3078/Depend/: BSP_SD3078.c BSP_SD3078.h
  group Mod_SysClock
    ../Module/Mod_SysClock/Src/: Mod_SysClock.c Mod_SysClock.h
  group Mod_SysClock/Depend
    ../Module/Mod_SysClock/Depend/: BSP_CLK.c BSP_CLK.h
  group Mod_Systemtick
    ../Module/Mod_Systemtick/Src/: Mod_SystemTick.c Mod_SystemTick.h
  group Mod_Systemtick/Depend
    ../Module/Mod_Systemtick/Depend/: BSP_Systick.c BSP_Systick.h
