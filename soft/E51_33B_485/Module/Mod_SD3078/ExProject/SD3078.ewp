# IAR project SD3078.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: SD3078.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: ExMain.c
  group Mod_SD3078
    ../Src/: Mod_SD3078.c Mod_SD3078.h
  group Mod_SD3078/Depend
    ../Depend/: BSP_SD3078.c BSP_SD3078.h
  group Mod_SysClock
    ../../Mod_SysClock/Src/: Mod_SysClock.c Mod_SysClock.h
  group Mod_SysClock/Depend
    ../../Mod_SysClock/Depend/: BSP_CLK.c BSP_CLK.h
  group Mod_Systemtick
    ../../Mod_Systemtick/Src/: Mod_SystemTick.c Mod_SystemTick.h
  group Mod_Systemtick/Depend
    ../../Mod_Systemtick/Depend/: BSP_Systick.c BSP_Systick.h
