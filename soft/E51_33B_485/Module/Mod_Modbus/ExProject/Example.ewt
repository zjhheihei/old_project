<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data/>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data/>
    </settings>
  </configuration>
  <group>
    <name>Mod_ModbusSlave</name>
    <group>
      <name>Depend</name>
      <file>
        <name>$PROJ_DIR$\..\Depend\BSP_SlaveUart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Depend\BSP_SlaveUart.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\Src\Mod_ModbusSlave.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\Mod_ModbusSlave.h</name>
    </file>
  </group>
  <group>
    <name>Mod_SysClock</name>
    <group>
      <name>Depend</name>
      <file>
        <name>$PROJ_DIR$\..\..\Mod_SysClock\Depend\BSP_CLK.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Mod_SysClock\Depend\BSP_CLK.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\Mod_SysClock\Src\Mod_SysClock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Mod_SysClock\Src\Mod_SysClock.h</name>
    </file>
  </group>
  <group>
    <name>Mod_Systemtick</name>
    <group>
      <name>Depend</name>
      <file>
        <name>$PROJ_DIR$\..\..\Mod_Systemtick\Depend\BSP_Systick.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Mod_Systemtick\Depend\BSP_Systick.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\Mod_Systemtick\Src\Mod_SystemTick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Mod_Systemtick\Src\Mod_SystemTick.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\ExMain.c</name>
  </file>
</project>


