# IAR project Example.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\\..\Mod_Backlight\Depend; ..\\..\Mod_Backlight\ExProject; ..\\..\Mod_Backlight\Src; ..\\..\Mod_Keyboard\Depend; ..\\..\Mod_Keyboard\Src; ..\\..\Mod_SysClock1\Depend; ..\\..\Mod_SysClock1\Src; ..\Depend; ..\Src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Example.srec
  ILINK.IlinkOutputFile: Example.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: ExMain.c
  group Mod_Backlight
    ../../Mod_Backlight/Src/: Mod_Backlight.c Mod_Backlight.h
  group Mod_Backlight/Depend
    ../../Mod_Backlight/Depend/: BSP_Backlight.c BSP_Backlight.h
  group Mod_Keyboard
    ../../Mod_Keyboard/Src/: Mod_Keyboard.c Mod_Keyboard.h
  group Mod_Keyboard/Depend
    ../../Mod_Keyboard/Depend/: BSP_Keyboard.c BSP_Keyboard.h
  group Mod_LCD
    ../Src/: Mod_LCD.c Mod_LCD.h
  group Mod_LCD/Depend
    ../Depend/: BSP_LCD.c BSP_LCD.h
  group Mod_SD3078
    ../../Mod_SD3078/Src/: Mod_SD3078.c Mod_SD3078.h
  group Mod_SD3078/Depend
    ../../Mod_SD3078/Depend/: BSP_SD3078.c BSP_SD3078.h
  group Mod_SysClock
    ../../Mod_SysClock/Src/: Mod_SysClock.c Mod_SysClock.h
  group Mod_SysClock/Depend
    ../../Mod_SysClock/Depend/: BSP_CLK.c BSP_CLK.h
  group Mod_Systemtick
    ../../Mod_Systemtick/Src/: Mod_SystemTick.c Mod_SystemTick.h
  group Mod_Systemtick/Depend
    ../../Mod_Systemtick/Depend/: BSP_Systick.c BSP_Systick.h
