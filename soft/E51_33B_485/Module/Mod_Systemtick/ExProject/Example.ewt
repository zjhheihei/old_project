<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Mod_Systemtick</name>
    <group>
      <name>Depend</name>
      <file>
        <name>$PROJ_DIR$\..\Depend\BSP_Systick.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Depend\BSP_Systick.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Depend\iostm8l052r8.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\Src\Mod_SystemTick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\Mod_SystemTick.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\ExMain.c</name>
  </file>
</project>


