# IAR project RelayPWMDemo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: ExMain.c
  group Mod_Keyboard
    ../../Mod_Keyboard/Src/: Mod_Keyboard.c Mod_Keyboard.h
  group Mod_Keyboard/Depend
    ../../Mod_Keyboard/Depend/: BSP_Keyboard.c BSP_Keyboard.h
  group Mod_Relay
    ../Src/: Mod_RelayPWM.c Mod_RelayPWM.h
  group Mod_Relay/Depend
    ../Depend/: BSP_RelayPWM.c BSP_RelayPWM.h
  group Mod_SysClock
    ../../Mod_SysClock/Depend/: BSP_CLK.c BSP_CLK.h
    ../../Mod_SysClock/Src/: Mod_SysClock.c Mod_SysClock.h
  group Mod_Systemtick
    ../../Mod_Systemtick/Src/: Mod_SystemTick.c Mod_SystemTick.h
  group Mod_Systemtick/Depend
    ../../Mod_Systemtick/Depend/: BSP_Systick.c BSP_Systick.h
