<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\hd_rt1.36t.ewp</path>
  </project>
  <batchBuild/>
</workspace>


