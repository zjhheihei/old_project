# IAR project hd_rt1.23i.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L136K8TA HDSC HC32L136K8TA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\application; ..\..\public\drive\inc; ..\..\public\startup; ..\..\public; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: testPrj3.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: D:\2020\work\2020\github\me\old_project\soft\rt1\project\hd_rt1.23i\hc32l136.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: hd_rt1.23i.bin
  ILINK.IlinkIcfFile: hc32l136_bootlaod.icf
  group application
    ../../application/: app_backlight.c app_backlight.h app_cfg.h app_control.c app_control.h app_display.c app_display.h app_interval.c app_interval.h app_key.c app_key.h app_main.c app_outputLogic.c app_outputLogic.h app_relay.c app_relay.h app_softRtc.c app_softRtc.h app_storage.c app_storage.h app_timming.c app_timming.h app_tuyaInterface.c app_tuyaInterface.h app_updateFromWIFI.c app_updateFromWIFI.h app_wifi.c app_wifi.h interrupts_hc32l136.c interrupts_hc32l136.h
    ./: DeviceSelect.h
  group application/app_tuya_sdk
    ../../application/app_tuya_sdk/: tuya_mcu_api.c tuya_mcu_api.h tuya_protocol.c tuya_protocol.h tuya_system.c tuya_system.h tuya_wifi.h
  group module/mod_backllight
    ../../module/mod_backlight/depend/: bsp_backlight.c bsp_backlight.h
    ../../module/mod_backlight/: mod_backlight.c mod_backlight.h
  group module/mod_key
    ../../module/mod_key/: mod_key.c mod_key.h
  group module/mod_key/depend
    ../../module/mod_key/depend/: bsp_key.c bsp_key.h
  group module/mod_lcd
    ../../module/mod_lcd_ls3/: mod_lcd_ls3.c mod_lcd_ls3.h
  group module/mod_lcd/depend
    ../../module/mod_lcd_ls3/depend/: bsp_lcd_ls3.c bsp_lcd_ls3.h
  group module/mod_ntc3380
    ../../module/mod_ntc3380/: mod_ntc3380.c mod_ntc3380.h
  group module/mod_ntc3380/depend
    ../../module/mod_ntc3380/depend/: bsp_ntc3380.c bsp_ntc3380.h
  group module/mod_relay
    ../../module/mod_relay/: mod_relay.c mod_relay.h
  group module/mod_relay/depend
    ../../module/mod_relay/depend/: bsp_relay.c bsp_relay.h
  group module/mod_storage
    ../../module/mod_storage/: mod_storage.c mod_storage.h
  group module/mod_storage/depend
    ../../module/mod_storage/depend/: bsp_crc8.c bsp_crc8.h BSP_FlashMemory.c BSP_FlashMemory.h
  group module/mod_sysClock
    ../../module/mod_sysClock/: mod_sysClock.c mod_sysClock.h
  group module/mod_sysClock/depend
    ../../module/mod_sysClock/depend/: BSP_CLOCK.c BSP_CLOCK.h
  group module/mod_systick
    ../../module/mod_systemTick/: mod_systemTick.c mod_systemTick.h
  group module/mod_systick/depend
    ../../module/mod_systemTick/Depend/: BSP_Systick.c BSP_Systick.h
  group module/mod_uartFull
    ../../module/mod_uartFull/: mod_uartFull.c mod_uartFull.h
  group module/mod_uartFull/depend
    ../../module/mod_uartFull/depend/: bsp_uartFull.c bsp_uartFull.h
  group module/mod_watchDog
    ../../module/mod_watchDog/: mod_watchdog.c
    ../../module/mod_watchdog/: mod_watchdog.h
  group module/mod_watchDog/depend
    ../../module/mod_watchDog/depend/: BSP_WDT.c BSP_WDT.h
  group public
    ../../public/: base_types.h ddl_device.h hc32l136.h system_hc32l136.c system_hc32l136.h
  group public/drive
    ../../public/drive/src/: adc.c ddl.c flash.c gpio.c lcd.c lpm.c sysctrl.c uart.c wdt.c
    ../../public/drive/inc/: adc.h ddl.h flash.h gpio.h lcd.h lpm.h sysctrl.h uart.h wdt.h
  group public/startup
    ../../public/startup/: startup_hc32l136.s
