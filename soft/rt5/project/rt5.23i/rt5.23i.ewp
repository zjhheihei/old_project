# IAR project rt5.23i.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCIncludePath2: $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: rt5.23i.hex
  ILINK.IlinkOutputFile: ls3_tuya.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8l052r8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: rt5.23i.bin
  ILINK.IlinkIcfFile: app_lnkstm8l052r8.icf
  group application
    ../../application/: app_backlight.c app_backlight.h app_cfg.h app_control.c app_control.h app_display.c app_display.h app_interval.c app_interval.h app_key.c app_key.h app_main.c app_openWindow.c app_openWindow.h app_outputLogic.c app_outputLogic.h app_preheating.c app_preheating.h app_relay.c app_relay.h app_softRtc.c app_softRtc.h app_storage.c app_storage.h app_timming.c app_timming.h app_tuyaInterface.c app_tuyaInterface.h app_updateFromWIFI.c app_updateFromWIFI.h app_wifi.c app_wifi.h
    ./: DeviceSelect.h
  group application/app_tuya_sdk
    ../../application/app_tuya_sdk/: tuya_mcu_api.c tuya_mcu_api.h tuya_protocol.c tuya_protocol.h tuya_system.c tuya_system.h tuya_wifi.h
  group module/mod_backlight
    ../../module/mod_backlight/: mod_backlight.c mod_backlight.h
  group module/mod_backlight/depend
    ../../module/mod_backlight/depend/: bsp_backlight.c bsp_backlight.h
  group module/mod_key
    ../../module/mod_key/: mod_key.c mod_key.h
  group module/mod_key/depend
    ../../module/mod_key/depend/: bsp_key.c bsp_key.h
  group module/mod_lcd_ls3
    ../../module/mod_lcd_ls3/: mod_lcd_ls3.c mod_lcd_ls3.h
  group module/mod_lcd_ls3/depend
    ../../module/mod_lcd_ls3/depend/: bsp_lcd_ls3.c bsp_lcd_ls3.h
  group module/mod_ntc3380
    ../../module/mod_ntc3380/: mod_ntc3380.c mod_ntc3380.h
  group module/mod_ntc3380/depend
    ../../module/mod_ntc3380/depend/: bsp_ntc3380.c bsp_ntc3380.h
  group module/mod_real_time
    ../../module/mod_real_time/: mod_real_time.c mod_real_time.h
  group module/mod_real_time/depend
    ../../module/mod_real_time/depend/: bsp_real_time.c bsp_real_time.h
  group module/mod_relay
    ../../module/mod_relay/: mod_relay.c mod_relay.h
  group module/mod_relay/depend
    ../../module/mod_relay/depend/: bsp_relay.c bsp_relay.h
  group module/mod_storage
    ../../module/mod_storage/: mod_storage.c mod_storage.h
  group module/mod_storage/depend
    ../../module/mod_storage/depend/: bsp_crc8.c bsp_crc8.h BSP_FlashMemory.c BSP_FlashMemory.h
  group module/mod_sysClock
    ../../module/mod_sysClock/: mod_sysClock.c mod_sysClock.h
  group module/mod_sysClock/depend
    ../../module/mod_sysClock/depend/: BSP_CLOCK.c BSP_CLOCK.h
  group module/mod_systemTick
    ../../module/mod_systemTick/: mod_systemTick.c mod_systemTick.h
  group module/mod_systemTick/depend
    ../../module/mod_systemTick/Depend/: BSP_Systick.c BSP_Systick.h
  group module/mod_uartFull
    ../../module/mod_uartFull/: mod_uartFull.c mod_uartFull.h
  group module/mod_uartFull/depend
    ../../module/mod_uartFull/depend/: bsp_uartFull.c bsp_uartFull.h
  group module/mod_watchDog
    ../../module/mod_watchDog/: mod_watchdog.c
    ../../module/mod_watchdog/: mod_watchdog.h
  group module/mod_watchDog/depend
    ../../module/mod_watchDog/depend/: BSP_WDT.c BSP_WDT.h
  group public/pbc_ringQueue
    ../../public/pbc_ringQueue/: pbc_ringQueue.c pbc_ringQueue.h
