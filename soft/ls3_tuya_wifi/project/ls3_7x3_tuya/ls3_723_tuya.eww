<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ls3_723_tuya.ewp</path>
  </project>
  <batchBuild/>
</workspace>


